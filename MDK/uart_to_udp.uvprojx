# Keil uVision project uart_to_udp.uvprojx, settings and files
target uart_to_udp (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: uart_to_udp
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\MDK_uart_to_udp;..\Libraries\CMSIS\Device\WIZnet\W7500\Source\ARM;..\Libraries\CMSIS\Device\WIZnet\W7500\Include;..\Libraries\W7500x_stdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\ioLibrary\Application\loopback;..\ioLibrary\Ethernet;..\ioLibrary\MDIO;..\ioLibrary\Application\my_dac
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group MDK_ARM
    ../Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x.s
  group W7500x_Periph
    ../Libraries/W7500x_stdPeriph_Driver/src/: W7500x_crg.c W7500x_dma.c W7500x_gpio.c W7500x_uart.c W7500x_wztoe.c
  group CMSIS
    ../Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group USER
    ../: main.c W7500x_it.c retarget.c
  group ioLibrary
    ../ioLibrary/Ethernet/: socket.c wizchip_conf.c
    ../ioLibrary/MDIO/: W7500x_miim.c
  group Applications
    ../ioLibrary/Application/loopback/: loopback.c
    ../ioLibrary/Application/my_dac/: my_dac.c
